<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\AppliNonSecure\Claritone_Camera_Driver_AppliNonSecure.ewp</path>
  </project><project>
    <path>$WS_DIR$\FSBL\Claritone_Camera_Driver_FSBL.ewp</path>
  </project><project>
    <path>$WS_DIR$\AppliSecure\Claritone_Camera_Driver_AppliSecure.ewp</path>
  </project>
  <batchBuild />
</workspace>
